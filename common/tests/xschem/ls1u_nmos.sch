** sch_path: common/tests/xschem/ls1u_nmos.sch
**.subckt ls1u_nmos
x1 d in 0 0 LV1UNMOS w=1.5u l=1u m=1
v1 in 0 5
v2 d 0 5
**.ends
.end
