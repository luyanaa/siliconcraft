** sch_path: common/tests/xschem/openrule1um_nmos.sch
**.subckt openrule1um_nmos
m1 d in 0 0 or1_nmos w=2u l=1u m=1
v1 in 0 5
v2 d 0 5
**.ends
.end
