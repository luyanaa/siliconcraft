** sch_path: common/tests/xschem/tr1um_nmos.sch
**.subckt tr1um_nmos
m1 d in 0 0 NMOS_mst w=3.4u l=1u m=1
v1 in 0 5
v2 d 0 5
**.ends
.end
