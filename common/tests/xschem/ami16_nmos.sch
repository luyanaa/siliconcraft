** sch_path: common/tests/xschem/ami16_nmos.sch
**.subckt ami16_nmos
m1 d in 0 0 ami16N w=6u l=1.6u m=1
v1 in 0 5
v2 d 0 5
**.ends
.end
