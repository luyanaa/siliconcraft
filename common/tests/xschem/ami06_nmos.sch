** sch_path: common/tests/xschem/ami06_nmos.sch
**.subckt ami06_nmos
m1 d in 0 0 ami06N w=3u l=0.6u m=1
v1 in 0 3.3
v2 d 0 3.3
**.ends
.end
