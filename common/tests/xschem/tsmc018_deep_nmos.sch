** sch_path: common/tests/xschem/tsmc018_deep_nmos.sch
**.subckt tsmc018_deep_nmos
m1 d in 0 0 TSMC18dN w=1u l=0.18u m=1
v1 in 0 1.8
v2 d 0 1.8
**.ends
.end
