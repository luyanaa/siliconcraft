** sch_path: common/tests/xschem/tsmc025_deep_nmos.sch
**.subckt tsmc025_deep_nmos
m1 d in 0 0 tsmc25dN w=1.5u l=0.24u m=1
v1 in 0 2.5
v2 d 0 2.5
**.ends
.end
