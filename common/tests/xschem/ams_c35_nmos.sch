** sch_path: common/tests/xschem/ams_c35_nmos.sch
**.subckt ams_c35_nmos
m1 d in 0 0 c35N w=3u l=0.6u m=1
v1 in 0 3.3
v2 d 0 3.3
**.ends
.end
