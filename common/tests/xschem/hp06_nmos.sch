** sch_path: common/tests/xschem/hp06_nmos.sch
**.subckt hp06_nmos
m1 d in 0 0 hp14tbN w=3u l=0.6u m=1
v1 in 0 5
v2 d 0 5
**.ends
.end
