** sch_path: common/tests/xschem/tsmc035_4m2p_nmos.sch
**.subckt tsmc035_4m2p_nmos
m1 d in 0 0 tsmc35N w=1.5u l=0.6u m=1
v1 in 0 3.3
v2 d 0 3.3
**.ends
.end
